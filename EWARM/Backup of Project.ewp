# IAR project Backup of Project.ewp, settings and files
configuration 5G_TEST_JIG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KT_5G_TEST_JIG.bin
  prebuild: touch.EXE ..\main.c
  ILINK.IlinkOutputFile: KT_5G_TEST_JIG.out
  ILINK.IlinkIcfFile: stm32f10x_flash_IAP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../: AlarmComm.c command.c config.c config.h debug.c I2CRoutines.c I2CRoutines.h main.c md5.c ping.c rabm.c rabm.h stm32f10x_it.c Time.c util.c
    ../W5200/: config.h
    ../W5500/: dhcp.c socket.c
  group User/W5500
    ../W5500/: loopback.c sockutil.c SPI2.c telnet.c util_DHCP.c w5500.c
